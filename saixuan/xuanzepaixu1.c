#include <stdio.h>
#define swap(a,b) { int temp = (a);\
					(a) = (b);\
					(b) = (temp);}
void sort(int [], int);
void sortrev(int [], int);

int main(int argc, char *argv[]){
	int num[]={1,34,24,56,34,90,78,100,67,90,99,2,80,20};
	int i, rever, high = sizeof(num) / sizeof(int) - 1;

	if(argc == 2 && (*++argv)[0] == '-' && (*argv)[1] == 'v' )
		sortrev(num, high);
	else
		sort(num, high);

	for(i = 0; i<= high; i++){
		printf("%d ",num[i]);
	}
	printf("\n");

	return 0;
}

void sortrev(int num[], int high){
	int i, maxid;
	do{
		maxid = 0;
		for(i = 0; i <= high; i++)
			if (num[i] < num[maxid])
				maxid = i;
		if(i != maxid)	
			swap(num[maxid],num[high]);
	}while(--high > 0);
}

void sort(int num[], int high){
	int i, maxid;
	do{
		maxid = 0;
		for(i = 0; i <= high; i++)
			if (num[i] > num[maxid])
				maxid = i;
		if(i != maxid)	
			swap(num[maxid],num[high]);
	}while(--high > 0);
}
