#include <stdio.h>
int findptr(int, int [], int);

int main(void) {

	int ptr, key = 2001,high;
	int num[]={2,6,90,140,280,330,560,770,1000,2001,3500,4200,4500};
	high = sizeof(num)/sizeof(int);

	if ((ptr = findptr(key,num,high)) > 0 )
		printf("Found %d in num[%d]\n",key, ptr);
	else 
		printf("Not found %d in num[]\n",key);

	return 0;
}

int findptr(int key, int num[], int high){

	int low = 0, ptr;
	while(low <= high){
		ptr = (low+high)/2;
		if(num[ptr] == key)
			return ptr;
		else if(num[ptr] > key)
			high = ptr -1;
		else
			low = ptr + 1;
	}
	return 0;
}
